Commit message: left foot as priority

File: template_project/human.urdf (robot description, URDF)
Before this commit: robot human, 33 links, 32 joints
Joints:
- joint right_knee: origin xyz=0 0 0.4 rpy=0 0 0 -> xyz=0 0 0.4 rpy=0.00 0 0
